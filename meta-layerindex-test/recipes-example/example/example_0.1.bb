SUMMARY = "Example recipe"
DESCRIPTION = "An example recipe used to test the OE layer index update script"
LICENSE = "MIT"

