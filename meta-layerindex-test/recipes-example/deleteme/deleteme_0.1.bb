SUMMARY = "Test recipe for deletion"
LICENSE = "MIT"

