SUMMARY = "Test recipe"
LICENSE = "MIT"

